# Keil uVision project stmf411_uart_middle.uvprojx, settings and files
target stmf411_uart_middle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stmf411_uart_middle +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/uart_proto/inc;..\Middlewares\Third_Party\SystemView\inc;..\Middlewares\uart_send\inc;..\02_OS_Platform\OS_Implementation\FreeRTOS\inc;..\02_OS_Platform\OS_Wrapper\inc;..\02_OS_Platform\OS_Adapter\inc;..\04_Debug_Tool;..\04_Debug_Tool\easylogger\inc;..\04_Debug_Tool\RTT
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group 02_OS_Platform/OS_Wrapper
    ../02_OS_Platform/OS_Wrapper/src/: osal_heap.c osal_mutex.c osal_queue.c osal_sema.c osal_task.c osal_timer.c
  group 02_OS_Platform/OS_Implementation
    ../02_OS_Platform/OS_Implementation/FreeRTOS/src/: os_impl_heap.c os_impl_mutex.c os_impl_queue.c os_impl_sema.c os_impl_task.c os_impl_timer.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middle_layer
    ../Middlewares/uart_proto/src/: uart_proto.c t_list.c
    ../Middlewares/uart_send/src/: uart_send.c
  group Middlewares/SystemView
    ../Middlewares/Third_Party/SystemView/src/: SEGGER_SYSVIEW.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_Config_FreeRTOS.c
  group Debug/Port
    ../04_Debug_Tool/: Debug.c
  group Debug/RTT
    ../04_Debug_Tool/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../04_Debug_Tool/easylogger/port/: elog_port.c
    ../04_Debug_Tool/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
